EXTRA_QMAKEVARS_PRE = "CONFIG+=webcam"
