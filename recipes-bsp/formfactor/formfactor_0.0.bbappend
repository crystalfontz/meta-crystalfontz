# Append path for including custom machconfig
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
