include linux-cfa.inc

PR = "r4"

SRC_BRANCH = "cfa-3.12.17"
SRCREV = "65261bd5ad1f9e8d735cb52923d1a2b4906d2991"

#SRC_BRANCH = "cfa-3.12.16"
#SRCREV = "33cc124832f2a6d1fc40ef63fad4c7055f98a001"

#SRC_BRANCH = "cfa-3.12.15"
#SRCREV = "3a0ea05548d2a4f7bc0da8f1723e2a9f7f43d2c2"

#SRC_BRANCH = "cfa-3.12.14"
#SRCREV = "6e2d67727fc07d822e70840e69f4bd3a02842aa2"

#SRC_BRANCH = "cfa-3.12.13"
#SRCREV = "85b2779d5dedf340ac38d1e22b664ec452fe9e77"

#SRC_BRANCH = "cfa-3.12.8"
#SRCREV = "4ec144fcda849c355747e0d0f28cbc50752b5274"

#SRC_BRANCH = "cfa-3.12.6"
#SRCREV = "39ceaa0f7d0c19032790699a9dc29ceff7ce48a5"

COMPATIBLE_MACHINE = "cfa10036"
